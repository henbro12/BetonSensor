<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\blinky_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\mbr\iar\blinky_pca10056_mbr.ewp</path>
  </project>  <batchBuild/>
</workspace>
